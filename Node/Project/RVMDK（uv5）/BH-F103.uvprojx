# Keil uVision project BH-F103.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08002000,0xDC00) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: fromelf --bin --output ..\..\Output\app.bin ..\..\Output\output.axf
  AfterMake: python ..\..\..\Tool\fw_pack.py
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\APP;..\..\BSP;..\..\Main;..\..\Wifi
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xdc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ../../Main/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group App
    ../../App/: app_init.c app_init.h app_tasks.c app_tasks.h app_global.h
    ../../APP/: app_version.h
  group BSP
    ../../BSP/: bsp_usart.c bsp_usart.h bsp_led.c bsp_led.h bsp_delay.c bsp_delay.h bsp_ultrasonic.c bsp_ultrasonic.h bsp_oled.c bsp_oled.h bsp_oledfont.h bsp_qmc5883p.c bsp_qmc5883p.h lora_node.c lora_node.h
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    ../../Doc/: readme.txt
