# Keil uVision project Boot.uvprojx, settings and files
target Boot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: boot +hex
  AfterMake: fromelf --bin --output ..\..\..\..\Output\boot\boot.bin ..\..\..\..\Output\boot\boot.axf
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\..\;..\..\..\..\Libraries\CMSIS;..\..\..\..\Libraries\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BootLoader
    ../../../: main.c boot.h boot_cfg.h
  group STARTUP
    ../../../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../../../Libraries/FWlib/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_usart.c
